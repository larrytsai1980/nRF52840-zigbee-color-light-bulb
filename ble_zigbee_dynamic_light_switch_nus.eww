<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\ble_zigbee_dynamic_light_switch_nus_pca10056_s140.ewp</path>
  </project>  <batchBuild/>
</workspace>